# Keil uVision project 05_AdvancedTimer.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 05_AdvancedTimer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User\MyLib\AdvanceTimer;.\User\MyLib\GPIO;.\User\MyLib\RCC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ./User/Application/: main.c
  group Inc
    ./User/MyLib/AdvanceTimer/: AdvancedTimer.h
    ./User/MyLib/GPIO/: GPIO.h
    ./User/MyLib/RCC/: RCC.h
  group Src
    ./User/MyLib/RCC/: RCC.c
    ./User/MyLib/GPIO/: GPIO.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
