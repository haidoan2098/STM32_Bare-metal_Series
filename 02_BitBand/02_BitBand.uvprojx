# Keil uVision project 02_BitBand.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 02_BitBand
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\User\MyLib\BitBand;.\User\MyLib\GPIO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./User/Application/: main.c
  group Inc
    ./User/MyLib/BitBand/: BITBAND.h
    ./User/MyLib/GPIO/: GPIO.h
  group Src
    ./User/MyLib/GPIO/: GPIO.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
